# Keil uVision project ATK_ESP8266.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK_ESP8266 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ATK-ESP8266;..\CORE;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART3;..\HARDWARE\W25QXX;..\MALLOC;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USER;..\USMART;..\HARDWARE\BLE;..\HARDWARE\GESTURE;..\HARDWARE\INTEL_WINDOW;..\HARDWARE\KMP;..\HARDWARE\LIGHT;..\HARDWARE\MUSIC;..\HARDWARE\PAJ7620U2;..\HARDWARE\USART2;..\HARDWARE\VOICE;..\HARDWARE\WINDOW;..\HARDWARE\PAJ7620U2;..\HARDWARE\UART4;..\HARDWARE\VIEW
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/BLE/: ble.c
    ../HARDWARE/GESTURE/: gesture.c
    ../HARDWARE/INTEL_WINDOW/: intel_window.c
    ../HARDWARE/KMP/: kmp.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/MUSIC/: music.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/WINDOW/: window.c
    ../HARDWARE/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/VIEW/: view.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group ATK_ESP8266
    ../ATK-ESP8266/: common.c wifista.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
